# Keil uVision project tryWinc.uvprojx, settings and files
target tryWinc (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F410RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: tryWinc +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F410Rx,CONF_WINC_USE_SPI,NM_EDGE_INTERRUPT,CONF_WINC_DEBUG
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\config;..\bsp\include;..\bus_wrapper\include;..\common\include;..\driver\include;..\driver\source;..\socket\include;..\socket\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f410rx.s
  group bsp
    ../bsp/source/: nm_bsp_samd21.c
  group bus_wrapper
    ../bus_wrapper/source/: nm_bus_wrapper_samd21.c
  group common
    ../common/source/: nm_common.c
  group driver
    ../driver/source/: m2m_hif.c m2m_hif.h m2m_ota.c m2m_periph.c m2m_wifi.c nmasic.c nmasic.h nmbus.c nmbus.h nmdrv.c nmdrv.h nmi2c.c nmi2c.h nmspi.c nmspi.h nmuart.c nmuart.h
  group socket
    ../socket/source/: socket.c
  group config
    ../config/: conf_board - Copy.h conf_board.h conf_clocks.h conf_extint.h conf_spi.h conf_winc.h
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
